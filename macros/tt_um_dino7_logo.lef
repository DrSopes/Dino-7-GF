VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO tt_um_dino7_logo
  CLASS BLOCK ;
  FOREIGN tt_um_dino7_logo ;
  ORIGIN 0.000 0.000 ;
  SIZE 26.600 BY 13.440 ;
  OBS
      LAYER Metal1 ;
        RECT 3.080 10.640 6.160 10.920 ;
        RECT 20.160 10.640 23.800 10.920 ;
        RECT 2.800 10.360 6.440 10.640 ;
        RECT 2.800 10.080 6.720 10.360 ;
        RECT 2.800 9.800 7.000 10.080 ;
        RECT 2.800 7.560 4.200 9.800 ;
        RECT 5.320 9.520 7.280 9.800 ;
        RECT 5.600 7.840 7.280 9.520 ;
        RECT 5.320 7.560 7.280 7.840 ;
        RECT 2.800 7.280 7.280 7.560 ;
        RECT 2.800 6.720 7.000 7.280 ;
        RECT 2.800 6.440 6.720 6.720 ;
        RECT 7.560 6.440 9.240 10.080 ;
        RECT 9.520 9.520 11.200 10.080 ;
        RECT 9.520 9.240 11.480 9.520 ;
        RECT 11.760 9.240 13.160 10.080 ;
        RECT 14.280 9.520 16.520 10.080 ;
        RECT 19.880 9.520 23.800 10.640 ;
        RECT 14.000 9.240 16.800 9.520 ;
        RECT 19.880 9.240 21.280 9.520 ;
        RECT 9.520 8.120 13.160 9.240 ;
        RECT 9.520 6.440 10.920 8.120 ;
        RECT 11.200 7.840 13.160 8.120 ;
        RECT 11.480 7.280 13.160 7.840 ;
        RECT 11.760 7.000 13.160 7.280 ;
        RECT 13.720 8.960 17.080 9.240 ;
        RECT 20.160 8.960 21.280 9.240 ;
        RECT 22.120 8.960 23.800 9.520 ;
        RECT 13.720 7.560 14.840 8.960 ;
        RECT 15.680 8.680 17.080 8.960 ;
        RECT 15.960 7.560 17.080 8.680 ;
        RECT 17.360 7.560 19.600 8.960 ;
        RECT 21.840 8.680 23.520 8.960 ;
        RECT 21.560 8.400 23.520 8.680 ;
        RECT 21.560 7.840 23.240 8.400 ;
        RECT 21.280 7.560 22.960 7.840 ;
        RECT 13.720 7.000 17.080 7.560 ;
        RECT 21.280 7.280 22.680 7.560 ;
        RECT 21.000 7.000 22.680 7.280 ;
        RECT 12.040 6.440 13.160 7.000 ;
        RECT 14.000 6.720 16.800 7.000 ;
        RECT 14.280 6.440 16.520 6.720 ;
        RECT 21.000 6.440 22.400 7.000 ;
        RECT 14.000 5.600 15.120 5.880 ;
        RECT 13.720 5.320 14.000 5.600 ;
        RECT 14.560 5.320 15.400 5.600 ;
        RECT 13.720 5.040 15.400 5.320 ;
        RECT 13.720 4.760 14.560 5.040 ;
        RECT 10.920 4.480 11.200 4.760 ;
        RECT 13.440 4.480 15.120 4.760 ;
        RECT 10.920 4.200 11.480 4.480 ;
        RECT 13.160 4.200 14.280 4.480 ;
        RECT 10.920 3.920 11.760 4.200 ;
        RECT 12.600 3.920 14.840 4.200 ;
        RECT 11.200 3.640 14.280 3.920 ;
        RECT 11.480 3.360 14.000 3.640 ;
        RECT 11.760 3.080 14.000 3.360 ;
        RECT 12.040 2.800 12.880 3.080 ;
        RECT 12.040 2.520 12.600 2.800 ;
        RECT 13.160 2.520 13.440 3.080 ;
        RECT 12.040 2.240 12.320 2.520 ;
        RECT 13.160 2.240 13.720 2.520 ;
        RECT 12.040 1.960 12.600 2.240 ;
        RECT 13.440 1.960 14.000 2.240 ;
      LAYER Metal2 ;
        RECT 3.080 10.640 6.160 10.920 ;
        RECT 20.160 10.640 23.800 10.920 ;
        RECT 2.800 10.360 6.440 10.640 ;
        RECT 2.800 10.080 6.720 10.360 ;
        RECT 2.800 9.800 7.000 10.080 ;
        RECT 2.800 7.560 4.200 9.800 ;
        RECT 5.320 9.520 7.280 9.800 ;
        RECT 5.600 7.840 7.280 9.520 ;
        RECT 5.320 7.560 7.280 7.840 ;
        RECT 2.800 7.280 7.280 7.560 ;
        RECT 2.800 6.720 7.000 7.280 ;
        RECT 2.800 6.440 6.720 6.720 ;
        RECT 7.560 6.440 9.240 10.080 ;
        RECT 9.520 9.520 11.200 10.080 ;
        RECT 9.520 9.240 11.480 9.520 ;
        RECT 11.760 9.240 13.160 10.080 ;
        RECT 14.280 9.520 16.520 10.080 ;
        RECT 19.880 9.520 23.800 10.640 ;
        RECT 14.000 9.240 16.800 9.520 ;
        RECT 19.880 9.240 21.280 9.520 ;
        RECT 9.520 8.120 13.160 9.240 ;
        RECT 9.520 6.440 10.920 8.120 ;
        RECT 11.200 7.840 13.160 8.120 ;
        RECT 11.480 7.280 13.160 7.840 ;
        RECT 11.760 7.000 13.160 7.280 ;
        RECT 13.720 8.960 17.080 9.240 ;
        RECT 20.160 8.960 21.280 9.240 ;
        RECT 22.120 8.960 23.800 9.520 ;
        RECT 13.720 7.560 14.840 8.960 ;
        RECT 15.680 8.680 17.080 8.960 ;
        RECT 15.960 7.560 17.080 8.680 ;
        RECT 17.360 7.560 19.600 8.960 ;
        RECT 21.840 8.680 23.520 8.960 ;
        RECT 21.560 8.400 23.520 8.680 ;
        RECT 21.560 7.840 23.240 8.400 ;
        RECT 21.280 7.560 22.960 7.840 ;
        RECT 13.720 7.000 17.080 7.560 ;
        RECT 21.280 7.280 22.680 7.560 ;
        RECT 21.000 7.000 22.680 7.280 ;
        RECT 12.040 6.440 13.160 7.000 ;
        RECT 14.000 6.720 16.800 7.000 ;
        RECT 14.280 6.440 16.520 6.720 ;
        RECT 21.000 6.440 22.400 7.000 ;
        RECT 14.000 5.600 15.120 5.880 ;
        RECT 13.720 5.320 14.000 5.600 ;
        RECT 14.560 5.320 15.400 5.600 ;
        RECT 13.720 5.040 15.400 5.320 ;
        RECT 13.720 4.760 14.560 5.040 ;
        RECT 10.920 4.480 11.200 4.760 ;
        RECT 13.440 4.480 15.120 4.760 ;
        RECT 10.920 4.200 11.480 4.480 ;
        RECT 13.160 4.200 14.280 4.480 ;
        RECT 10.920 3.920 11.760 4.200 ;
        RECT 12.600 3.920 14.840 4.200 ;
        RECT 11.200 3.640 14.280 3.920 ;
        RECT 11.480 3.360 14.000 3.640 ;
        RECT 11.760 3.080 14.000 3.360 ;
        RECT 12.040 2.800 12.880 3.080 ;
        RECT 12.040 2.520 12.600 2.800 ;
        RECT 13.160 2.520 13.440 3.080 ;
        RECT 12.040 2.240 12.320 2.520 ;
        RECT 13.160 2.240 13.720 2.520 ;
        RECT 12.040 1.960 12.600 2.240 ;
        RECT 13.440 1.960 14.000 2.240 ;
      LAYER Metal3 ;
        RECT 3.080 10.640 6.160 10.920 ;
        RECT 20.160 10.640 23.800 10.920 ;
        RECT 2.800 10.360 6.440 10.640 ;
        RECT 2.800 10.080 6.720 10.360 ;
        RECT 2.800 9.800 7.000 10.080 ;
        RECT 2.800 7.560 4.200 9.800 ;
        RECT 5.320 9.520 7.280 9.800 ;
        RECT 5.600 7.840 7.280 9.520 ;
        RECT 5.320 7.560 7.280 7.840 ;
        RECT 2.800 7.280 7.280 7.560 ;
        RECT 2.800 6.720 7.000 7.280 ;
        RECT 2.800 6.440 6.720 6.720 ;
        RECT 7.560 6.440 9.240 10.080 ;
        RECT 9.520 9.520 11.200 10.080 ;
        RECT 9.520 9.240 11.480 9.520 ;
        RECT 11.760 9.240 13.160 10.080 ;
        RECT 14.280 9.520 16.520 10.080 ;
        RECT 19.880 9.520 23.800 10.640 ;
        RECT 14.000 9.240 16.800 9.520 ;
        RECT 19.880 9.240 21.280 9.520 ;
        RECT 9.520 8.120 13.160 9.240 ;
        RECT 9.520 6.440 10.920 8.120 ;
        RECT 11.200 7.840 13.160 8.120 ;
        RECT 11.480 7.280 13.160 7.840 ;
        RECT 11.760 7.000 13.160 7.280 ;
        RECT 13.720 8.960 17.080 9.240 ;
        RECT 20.160 8.960 21.280 9.240 ;
        RECT 22.120 8.960 23.800 9.520 ;
        RECT 13.720 7.560 14.840 8.960 ;
        RECT 15.680 8.680 17.080 8.960 ;
        RECT 15.960 7.560 17.080 8.680 ;
        RECT 17.360 7.560 19.600 8.960 ;
        RECT 21.840 8.680 23.520 8.960 ;
        RECT 21.560 8.400 23.520 8.680 ;
        RECT 21.560 7.840 23.240 8.400 ;
        RECT 21.280 7.560 22.960 7.840 ;
        RECT 13.720 7.000 17.080 7.560 ;
        RECT 21.280 7.280 22.680 7.560 ;
        RECT 21.000 7.000 22.680 7.280 ;
        RECT 12.040 6.440 13.160 7.000 ;
        RECT 14.000 6.720 16.800 7.000 ;
        RECT 14.280 6.440 16.520 6.720 ;
        RECT 21.000 6.440 22.400 7.000 ;
        RECT 14.000 5.600 15.120 5.880 ;
        RECT 13.720 5.320 14.000 5.600 ;
        RECT 14.560 5.320 15.400 5.600 ;
        RECT 13.720 5.040 15.400 5.320 ;
        RECT 13.720 4.760 14.560 5.040 ;
        RECT 10.920 4.480 11.200 4.760 ;
        RECT 13.440 4.480 15.120 4.760 ;
        RECT 10.920 4.200 11.480 4.480 ;
        RECT 13.160 4.200 14.280 4.480 ;
        RECT 10.920 3.920 11.760 4.200 ;
        RECT 12.600 3.920 14.840 4.200 ;
        RECT 11.200 3.640 14.280 3.920 ;
        RECT 11.480 3.360 14.000 3.640 ;
        RECT 11.760 3.080 14.000 3.360 ;
        RECT 12.040 2.800 12.880 3.080 ;
        RECT 12.040 2.520 12.600 2.800 ;
        RECT 13.160 2.520 13.440 3.080 ;
        RECT 12.040 2.240 12.320 2.520 ;
        RECT 13.160 2.240 13.720 2.520 ;
        RECT 12.040 1.960 12.600 2.240 ;
        RECT 13.440 1.960 14.000 2.240 ;
  END
END tt_um_dino7_logo
END LIBRARY

